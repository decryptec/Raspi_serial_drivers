/dts-v1/;
/plugin/;
/ {
	compatible = "brcm,bcm2835";
	fragment@0 {
		target = <&uart0>;
		__overlay__ {
			echodev {
				compatible = "decryptec,echo_dev";
				status = "okay";
			};
		};
	};
};
